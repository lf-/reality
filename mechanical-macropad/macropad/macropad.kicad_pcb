# Repository lf-/reality

File README.md:

# reality
Documentation for physical projects

I make every effort to include files in open, editable formats for every
project. In most cases, this means that in addition to original Fusion 360
files, STEP files are also published, which can be opened in a free software
CAD program such as FreeCAD. If an additional format is required, please file
an issue on this repository.

All projects in this repository are licensed under the TAPR Open Hardware
License unless otherwise noted in their respective README files. A copy of the
license is available in the file LICENSE in the root directory of this
repository.

## KiCad design mechanical-macropad/macropad/macropad.kicad_pcb

Parts:
C1, C2: 22p; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4, C5, C6, C8, C9, C10, C11, C12, C14: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C7: 4.7u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C13: .1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28: D; D_SOD123_axial
D29, D30, D31, D32, D33: SK6812; LED_SK6812_PLCC4_5.0x5.0mm_P3.2mm
D34: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad
J1: USB_B_Micro; USB_Micro-B_Amphenol_10103594-0001LF_Horizontal
J2: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
K1, K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12, K13, K14, K15, K16, K17, K18, K19, K20, K21, K22, K23, K24, K25, K26, K27, K28: KEYSW; Mx_Alps_100
R1, R2: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R6: 330R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: SW_Push; Panasonic_EVQPUJ_EVQPUA
TP1: 5V0; TestPoint_Pad_D4.0mm
TP2: GND; TestPoint_Pad_D4.0mm
U1: ATMEGA32U4; TQFP-44_10x10mm_P0.8mm
Y1: Crystal_GND24; Crystal_SMD_SeikoEpson_FA238-4Pin_3.2x2.5mm_HandSoldering

Connections:
/D+: J1.3 (D+), R2.2
/D-: J1.2 (D-), R1.2
/DBG_LED: D34.2 (A), U1.19 (PD1/INT1)
/ISP_MISO: J2.1 (MISO), U1.11 (PB3/MISO)
/ISP_MOSI: J2.4 (MOSI), U1.10 (PB2/MOSI)
/ISP_RESET: C13.1, J2.5 (~RST), R3.2, SW1.2, U1.13 (~RESET)
/ISP_SCK: J2.3 (SCK), U1.9 (PB1/SCK)
/MCU_D+: R2.1, U1.4 (D+)
/MCU_D-: R1.1, U1.3 (D-)
/NEOPIXEL_IN: D29.2 (DIN), U1.20 (PD2/RXD1)
Col1: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), U1.31 (PC6)
Col2: D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), U1.30 (PB6)
Col3: D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), U1.29 (PB5)
Col4: D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), U1.28 (PB4)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D29.1 (VSS), D30.1 (VSS), D31.1 (VSS), D32.1 (VSS), D33.1 (VSS), H1.1, H2.1, H3.1, H4.1, J1.5 (GND), J1.6 (Shield), J2.6 (GND), R4.1, R5.2, R6.2, TP2.1, U1.5 (UGnd), U1.8 (PB0/SS), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), Y1.2, Y1.4
unnamed: C1.1, U1.16 (XTAL1), Y1.1
unnamed: C2.1, U1.17 (XTAL2), Y1.3
unnamed: C3.2, U1.6 (UCap)
unnamed: D1.2 (A), K1.1
unnamed: D2.2 (A), K2.1
unnamed: D3.2 (A), K3.1
unnamed: D4.2 (A), K4.1
unnamed: D5.2 (A), K5.1
unnamed: D6.2 (A), K6.1
unnamed: D7.2 (A), K7.1
unnamed: D8.2 (A), K8.1
unnamed: D9.2 (A), K9.1
unnamed: D10.2 (A), K10.1
unnamed: D11.2 (A), K11.1
unnamed: D12.2 (A), K12.1
unnamed: D13.2 (A), K13.1
unnamed: D14.2 (A), K14.1
unnamed: D15.2 (A), K15.1
unnamed: D16.2 (A), K16.1
unnamed: D17.2 (A), K17.1
unnamed: D18.2 (A), K18.1
unnamed: D19.2 (A), K19.1
unnamed: D20.2 (A), K20.1
unnamed: D21.2 (A), K21.1
unnamed: D22.2 (A), K22.1
unnamed: D23.2 (A), K23.1
unnamed: D24.2 (A), K24.1
unnamed: D25.2 (A), K25.1
unnamed: D26.2 (A), K26.1
unnamed: D27.2 (A), K27.1
unnamed: D28.2 (A), K28.1
unnamed: D29.4 (DOUT), D30.2 (DIN)
unnamed: D30.4 (DOUT), D31.2 (DIN)
unnamed: D31.4 (DOUT), D32.2 (DIN)
unnamed: D32.4 (DOUT), D33.2 (DIN)
unnamed: D34.1 (K), R6.1
unnamed: R4.2, U1.33 (~HWB/PE2)
unnamed: R5.1, SW1.1
Row1: K1.2, K8.2, K15.2, K22.2, U1.22 (PD5/XCK1)
Row2: K2.2, K9.2, K16.2, K23.2, U1.36 (PF7)
Row3: K3.2, K10.2, K17.2, K24.2, U1.37 (PF6)
Row4: K4.2, K11.2, K18.2, K25.2, U1.38 (PF5)
Row5: K5.2, K12.2, K19.2, K26.2, U1.39 (PF4)
Row6: K6.2, K13.2, K20.2, K27.2, U1.40 (PF1)
Row7: K7.2, K14.2, K21.2, K28.2, U1.41 (PF0)
VCC: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C14.1, D29.3 (VDD), D30.3 (VDD), D31.3 (VDD), D32.3 (VDD), D33.3 (VDD), J1.1 (VBUS), J2.2 (VCC), R3.1, TP1.1, U1.2 (UVcc), U1.7 (VBus), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)

Board: 2 copper layers, 76.0 x 176.4 mm, 93 parts (51 on the bottom side), 61 nets.

## Commit log

2018-05-19 Add TAPR Open Hardware License
2018-07-27 Add fan mount for 20mm extrusion
2018-07-27 These are scheme files, not Io
2018-08-05 Add apu2 rack mount bracket
2018-09-11 Add 2020 LCD bracket and y belt holder
2018-09-11 Add bed strain relief
2018-11-29 Initial PCB for a new macropad project
2018-11-29 fixup keebs.pretty submodule
2018-11-30 improve groundplanes, reroute
2018-11-30 Add debug LED, debug pads, reroute
2018-11-30 Add some trace spacing
2018-12-01 Final cleanup
2018-12-01 Add a beautiful VCC pour under the MCU to clean up traces
2018-12-10 Gild the lily: branding and removal of ugly GND trace
2018-12-10 Shift to portrait letter paper to make printable
2018-12-24 Add new parts for the Pegasus Z axis
2019-01-06 Add x-belt-holder
2019-01-06 Clarify licensing
2019-01-06 Improve readme
2019-01-30 Final touches
2019-01-30 Thicken power traces
2019-02-04 cleanup some traces
2019-02-04 Change R6 for a 330R
    This both reduces # of components and makes the debug LED less bright.
2019-02-22 BUG: C13 and R3 designators were ambiguous
2019-02-25 BUG: fix crystal footprint
    Somehow it got messed up in the assembled revision. This commit fixes it
    in a somewhat slapdash manner. Pull requests on this matter are welcome.
2019-02-27 Add Pegasus toolhead
    This is not of satisfactory quality in my opinion. Use this at your own
    risk.
2019-02-27 add drawing
2019-03-07 Tie slave select to ground
    This is probably pointless, but it guarantees that SPI communication will work.
2019-03-07 bump version
2019-05-06 add case for rc relay
2019-12-31 add coffee grinder adapter
2020-06-16 no gods no masters no master branches
2021-03-03 move mic stand off thingiverse

Notices in the files:
mechanical-macropad/macropad/macropad.kicad_pcb:
Copyright (c) 2019 lf
Licensed under TAPR Open Hardware License
